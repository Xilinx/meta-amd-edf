MALI_BACKEND_DEFAULT = "wayland"
