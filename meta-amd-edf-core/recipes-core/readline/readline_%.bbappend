# AMD EDF - Enhanced readline configuration

FILESEXTRAPATHS:prepend:amd-edf := "${THISDIR}/files:"
