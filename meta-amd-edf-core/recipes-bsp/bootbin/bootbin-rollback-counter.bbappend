BOOTBIN_ROLLBACK_COUNTER ?= "1"
BOOTBIN_ROLLBACK_COUNTER[doc] ?= "Rollback counter enforces that only firmware newer than the last applied version can be installed"
