BOOTBIN_VER_MAIN ?= "1.1"
BOOTBIN_VERSION_STRING ?= "amd-edf-${MACHINE}-bootfw-v${BOOTBIN_VER_MAIN}"
