FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://mount.sh-replace-blkid-lsblk-with-udev-env-vars.patch"
