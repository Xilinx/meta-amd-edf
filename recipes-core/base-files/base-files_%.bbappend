BASECAMP_INC = ""
BASECAMP_INC:basecamp = "base-files-basecamp.inc"
require ${BASECAMP_INC}
