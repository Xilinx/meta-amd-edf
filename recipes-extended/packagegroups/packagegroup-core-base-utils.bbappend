RDEPENDS:${PN}:remove:basecamp = "dhcpcd"
