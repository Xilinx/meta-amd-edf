require basecamp-image-common.inc
