IMGSEL_MC = "${MACHINE}-microblaze-pmc"
IMGSEL_DEPLOY_DIR = "${TMPDIR}-${IMGSEL_MC}/deploy/images/${MACHINE}"
