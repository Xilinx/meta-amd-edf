BOOTBIN_VER_MAIN:amd-edf ?= "1.1"
BOOTBIN_VERSION_STRING:amd-edf ?= "amd-edf-${MACHINE}-bootfw-v${BOOTBIN_VER_MAIN}"
