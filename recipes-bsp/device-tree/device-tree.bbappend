EXTRA_OVERLAYS:append:versal-vek280-sdt-seg-ospi = " system-conf.dtsi"
