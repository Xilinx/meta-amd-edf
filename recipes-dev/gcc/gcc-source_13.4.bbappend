# Backport change from YP master (bd04d43100df64c0d638750af664cdcde7f06411)
# TODO: Remove when no longer needed

inherit allarch
